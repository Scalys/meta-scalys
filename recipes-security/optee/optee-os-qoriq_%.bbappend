PLATFORM_FLAVOR:qls1046-4gb-dkb = "ls1046ardb"
PLATFORM_FLAVOR:qls1046-4gb-dk  = "ls1046ardb"
