# this file should be removed after meta-freescale update

SRC_URI = "git://github.com/NXP/qoriq-engine-pfe-bin.git;nobranch=1"
SRCREV = "f55ee9f72090309bbb7ab71f48a498fc02909234"
