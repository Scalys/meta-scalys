DESCRIPTION = "Manual QSPI flash script (U-Boot)"

include flash-fw.inc

DESCRIPTION = "Manual QSPI flash script (U-Boot)"

SCRIPT_SOURCE = "flash-fw.cmd"
SCRIPT_DEST = "flash-fw.scr"
SCRIPT_DESC = "QSPI firmware flash"