SRC_URI = "gitsm://github.com/Scalys/atf-qoriq.git;protocol=https;branch=trustbox-2108"
SRCREV = "b0c7f9c085c564e7dfaf5259376f456e3320fd90"

LIC_FILES_CHKSUM = "file://license.rst;md5=1dd070c98a281d18d9eefd938729b031"

chassistype = "ls104x_1012"

PLATFORM = "tbe101"


RCW_FOLDER_trustbox-edge-101 ?= "trustbox"
