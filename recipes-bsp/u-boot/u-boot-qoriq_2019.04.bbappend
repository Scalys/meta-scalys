SRC_URI = "git://github.com/Scalys/u-boot-qoriq.git;protocol=git;branch=scalys-2019.04"
SRCREV = "a84a008695102ab7cef7416ffeac1784475a0dba"
